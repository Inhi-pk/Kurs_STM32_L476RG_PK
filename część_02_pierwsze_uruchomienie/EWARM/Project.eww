<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\część_2_pierwsze_uruchomienie.ewp</path>
  </project>
  <batchBuild />
</workspace>
